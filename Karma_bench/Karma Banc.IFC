Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Karma Banc.IFC
Time: 2020-06-29T12:54:49
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBeam: KARM-BANC-003-F
In: Default Storey
PSet_Mass_Property - Mass Measure: 71.0895; Area Measure: 4.5018; Volume Measure: 0.0369235

# IfcBeam: KARM-BANC-011-B_Default
In: Default Storey
Material: Douka

# IfcBeam: KARM-BANC-013-B_Default
In: Default Storey
Material: Douka

# IfcBeam: KARM-BANQ-003_Default
In: Default Storey
Material: Douka

# IfcBeam: KARM-BANQ-004_Default
In: Default Storey
Material: Douka

# IfcBuildingElementProxy: KARM-BANC-010-B_Default
In: Default Storey
Material: Douka

# IfcBuildingElementProxy: KARM-BANC-012-B_Default
In: Default Storey
Material: Douka

# IfcBuildingElementProxy: KARM-BANC-014-C_Default
In: Default Storey
Material: S 235

# IfcBuildingElementProxy: KARM-BANQ-003_Default
In: Default Storey
Material: Douka

# IfcBuildingElementProxy: KARM-BANQ-004_Default
In: Default Storey
Material: Douka
